# Keil uVision project OnlineProgram.uvprojx, settings and files
target OnlineProgram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK64FX512xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IROM2(0x10000000,0x20000) IRAM(0x20000000,0x20000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OnlineProgram.axf
  AfterMake: fromelf --bin -o .\build\uvision5\bin\@L.bin .\build\uvision5\@L.axf
  c flags: Optim=1 uC99=1
  c define: MD5_SUPPORT=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DFEATURE_IPV4=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DMBED_BUILD_TIMESTAMP=1481254123.64 -DTARGET_K64F -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DTARGET_FRDM -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBEDTLS_ENTROPY_HARDWARE_ALT -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -D__MBED_CMSIS_RTOS_CM
  c include: .;mbed-rtos;mbed-rtos/rtx;mbed-rtos/rtx/TARGET_CORTEX_M;mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7;mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM;mbed-rtos/rtos;EthernetInterface;EthernetInterface/Socket;EthernetInterface/lwip-eth;EthernetInterface/lwip-eth/arch;EthernetInterface/lwip-eth/arch/TARGET_Freescale;EthernetInterface/lwip-sys;EthernetInterface/lwip-sys/arch;EthernetInterface/lwip;EthernetInterface/lwip/api;EthernetInterface/lwip/core;EthernetInterface/lwip/core/ipv4;EthernetInterface/lwip/core/snmp;EthernetInterface/lwip/include;EthernetInterface/lwip/include/ipv4;EthernetInterface/lwip/include/ipv4/lwip;EthernetInterface/lwip/include/lwip;EthernetInterface/lwip/include/netif;EthernetInterface/lwip/netif;EthernetInterface/lwip/netif/ppp;mbed/.;mbed/TARGET_K64F;mbed/TARGET_K64F/TARGET_Freescale;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/TARGET_FRDM;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/drivers;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api;mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;.\Program;.\TargetBoard;.\CRC16;.\C12832;.\cJSON;.\FreeScaleIAP;.\UUencode;.\SDFileSystem;.\SDFileSystem\FATFileSystem;.\SDFileSystem\FATFileSystem\ChaN;.\TargetBoard
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DFSL_RTOS_MBED,-DMBEDTLS_ENTROPY_HARDWARE_ALT,-D__CORTEX_M4,-D__FPU_PRESENT=1,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\mbed\TARGET_K64F\TOOLCHAIN_ARM_STD\MK64FN1M0xxx12.sct
  group Source
    ./: main.cpp mbed_config.h UserConfig.h
  group Program
    ./Program/: program.cpp program.h
  group TargetBoard
    ./TargetBoard/: LPC1125_FlashMap.h
  group CRC16
    crc16/: lib_crc16.cpp lib_crc16.h
  group UUencode
    ./UUencode/: UUencode.cpp UUencode.h
  group C12832
    ./C12832/: C12832.cpp C12832.h GraphicsDisplay.cpp GraphicsDisplay.h Small_7.h TextDisplay.cpp TextDisplay.h
  group cJSON
    cJSON/: cJSON.cpp cJSON.h
  group EthernetInterface
    EthernetInterface/: eth_arch.h EthernetInterface.cpp EthernetInterface.h
  group SDFileSystem
    ./SDFileSystem/: SDFileSystem.cpp SDFileSystem.h
    ./SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h MemFileSystem.h
    ./SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
  group FreeScaleIAP
    FreeScaleIAP/: FreescaleIAP.cpp FreescaleIAP.h
  group doc
    ./: readme.txt
  group Socket
    EthernetInterface/Socket/: Endpoint.cpp Endpoint.h Socket.cpp Socket.h TCPSocketConnection.cpp TCPSocketConnection.h TCPSocketServer.cpp TCPSocketServer.h UDPSocket.cpp UDPSocket.h
  group TARGET_CORTEX_M
    mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
  group TARGET_FRDM
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/TARGET_FRDM/: crc.h device.h fsl_clock_config.h fsl_phy.h PeripheralNames.h PinNames.h
  group TARGET_Freescale
    EthernetInterface/lwip-eth/arch/TARGET_Freescale/: hardware_init_MK64F12.c k64f_emac.c k64f_emac_config.h lwipopts_conf.h
  group TARGET_K64F
    mbed/TARGET_K64F/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/: peripheral_clock_defines.h
  group TOOLCHAIN_ARM
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.S
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar mbed_overrides.o retarget.o startup_MK64F12.o sys.o system_MK64F12.o
  group api
    EthernetInterface/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api/: gpio_object.h objects.h PeripheralPins.h PortNames.h
  group arch
    EthernetInterface/lwip-sys/arch/: cc.h checksum.c memcpy.c perf.h sys_arch.c sys_arch.h
  group core
    EthernetInterface/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group drivers
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/drivers/: fsl_adc16.h fsl_clock.h fsl_cmp.h fsl_cmt.h fsl_common.h fsl_crc.h fsl_dac.h fsl_dmamux.h fsl_dspi.h fsl_dspi_edma.h fsl_edma.h fsl_enet.h fsl_ewm.h fsl_flash.h fsl_flexbus.h fsl_flexcan.h fsl_ftm.h fsl_gpio.h fsl_i2c.h fsl_i2c_edma.h fsl_llwu.h fsl_lptmr.h fsl_mpu.h fsl_pdb.h fsl_pit.h fsl_pmc.h fsl_port.h fsl_rcm.h fsl_rnga.h fsl_rtc.h fsl_sai.h fsl_sai_edma.h fsl_sdhc.h fsl_sim.h fsl_smc.h fsl_uart.h fsl_uart_edma.h fsl_vref.h fsl_wdog.h
  group ipv4
    EthernetInterface/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip
    EthernetInterface/lwip/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
    EthernetInterface/lwip/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
    EthernetInterface/lwip/: lwipopts.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group netif
    EthernetInterface/lwip/netif/: etharp.c ethernetif.c slipif.c
    EthernetInterface/lwip/include/netif/: etharp.h ppp_oe.h slipif.h
  group ppp
    EthernetInterface/lwip/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h
  group rtos
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group snmp
    EthernetInterface/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
